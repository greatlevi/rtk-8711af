# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CONFIG_PLATFORM_8195A; ZC_MODULE_VERSION=0; ZC_MODULE_TYPE=9
  ICCARM.CCDiagSuppress: Be006,Pa050,Pa039,Pa089,Pe014,Pe047,Pe068,Pe089,Pe167,Pe177,Pe186,Pe188,Pe375,Pe550,Pe550,Pe223,Pe549,Pe550
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\common\bsp; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM3; ..\..\..\component\os\os_dep\include; ..\..\..\component\soc\realtek\8195a\misc\driver; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\application; ..\..\..\component\common\example; ..\..\..\component\common\example\wlan_fast_connect; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8195a; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\arch; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\netif\ppp; ..\..\..\component\common\test; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\soc\realtek\8195a\cmsis\device; ..\..\..\component\soc\realtek\8195a\fwlib; ..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\utilities; ..\..\..\component\soc\realtek\8195a\misc\rtl_std_lib\include; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\usb_otg\include; ..\..\..\component\common\video\v4l2\inc; ..\..\..\component\common\media\codec; ..\..\..\component\common\drivers\usb_class\host\uvc\inc; ..\..\src; ..\..\src\AC\inc; ..\..\src\ZC\inc\aes; ..\..\src\ZC\inc\tropicssl; ..\..\src\ZC\inc\zc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\os\os_dep\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM3
  OBJCOPY.OOCOutputFile: Project.srec
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\8195a\misc\iar_utility\common\prebuild.vbs" "$PROJ_DIR$"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\8195a\misc\iar_utility\common\postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$CONFIG_NAME$"
  ILINK.IlinkOutputFile: application.axf
  ILINK.IlinkKeepSymbols: bootloader; gImage2EntryFun0; RAM_IMG2_VALID_PATTEN
  ILINK.IlinkIcfFile: image2.icf
  ILINK.IlinkExtraOptions: --pi_veneers
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration UVC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_PLATFORM_8195A; CONFIG_UVC
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\common\bsp; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM3; ..\..\..\component\os\os_dep\include; ..\..\..\component\soc\realtek\8195a\misc\driver; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\application; ..\..\..\component\common\example; ..\..\..\component\common\example\wlan_fast_connect; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8195a; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek; ..\..\..\component\common\test; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\soc\realtek\8195a\cmsis\device; ..\..\..\component\soc\realtek\8195a\fwlib; ..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\utilities; ..\..\..\component\soc\realtek\8195a\misc\rtl_std_lib\include; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\usb_otg\include; ..\..\..\component\common\video\v4l2\inc; ..\..\..\component\common\media\codec; ..\..\..\component\common\drivers\usb_class\host\uvc\inc
  OBJCOPY.OOCOutputFile: application.srec
  group cmsis
    ../../../component/soc/realtek/8195a/cmsis/device/: system_8195a.c
  group console
    ../../../component/common/api/at_cmd/: atcmd_google.c atcmd_sys.c atcmd_wifi.c log_service.c
    ../../../component/soc/realtek/8195a/misc/driver/: low_level_io.c rtl_consol.c
  group lib
    ../../../component/soc/realtek/8195a/misc/bsp/lib/common/IAR/: lib_mdns.a lib_platform.a lib_rtlstd.a lib_usb.a lib_uvc.a lib_wlan.a lib_wps.a
    ../../../component/soc/realtek/8195a/misc/bsp/lib/va0/: rom.a
  group network/api
    ../../../component/common/api/: lwip_netconf.c wifi_interactive_mode.c
  group network/api/wifi
    ../../../component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
    ../../../component/common/drivers/wlan/realtek/src/: wifi_skbuf.c
  group network/api/wifi/rtw_wpa_supplicant
    ../../../component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_wps_config.c
  group network/app
    ../../../component/common/api/network/src/: ping_test.c rtl8195a_it.c wlan_network.c
    ../../../component/common/utilities/: ssl_client.c tcptest.c update.c
    ../../../component/common/application/uart_adapter/: uart_adapter.c
  group network/lwip
    ../../../component/common/network/dhcp/: dhcps.c
  group network/lwip/api
    ../../../component/common/network/lwip/lwip_v1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/core
    ../../../component/common/network/lwip/lwip_v1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group network/lwip/core/ipv4
    ../../../component/common/network/lwip/lwip_v1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group network/lwip/netif
    ../../../component/common/network/lwip/lwip_v1.4.1/src/netif/: etharp.c
  group network/lwip/port
    ../../../component/common/network/lwip/lwip_v1.4.1/port/realtek/freertos/: ethernetif.c sys_arch.c
    ../../../component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group network/mdns
    ../../../component/common/network/mdns/: mDNSPlatform.c
  group os/freertos
    ../../../component/os/freertos/: cmsis_os.c
    ../../../component/os/freertos/freertos_v8.1.2/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group os/freertos/portable
    ../../../component/os/freertos/freertos_v8.1.2/Source/portable/MemMang/: heap_5.c
    ../../../component/os/freertos/freertos_v8.1.2/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group os/osdep
    ../../../component/os/freertos/: freertos_service.c
    ../../../component/os/os_dep/: mailbox.c osdep_api.c osdep_service.c tcm_heap.c
  group peripheral/api
    ../../../component/common/mbed/targets/hal/rtl8195a/: analogin_api.c dma_api.c efuse1_api.c efuse2_api.c efuse3_api.c flash_api.c gpio_api.c gpio_irq_api.c i2c_api.c i2s_api.c nfc_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c sys_api.c timer_api.c us_ticker.c wdt_api.c
    ../../../component/common/mbed/common/: us_ticker_api.c wait_api.c
  group peripheral/hal
    ../../../component/soc/realtek/8195a/fwlib/src/: hal_32k.c hal_adc.c hal_gdma.c hal_gpio.c hal_i2c.c hal_i2s.c hal_mii.c hal_nfc.c hal_pcm.c hal_pwm.c hal_sdr_controller.c hal_soc_ps_monitor.c hal_ssi.c hal_timer.c hal_uart.c
  group peripheral/osdep
    ../../../component/os/freertos/: freertos_pmu.c
  group peripheral/rtl8195a
    ../../../component/soc/realtek/8195a/fwlib/rtl8195a/src/: rtl8195a_adc.c rtl8195a_gdma.c rtl8195a_gpio.c rtl8195a_i2c.c rtl8195a_i2s.c rtl8195a_nfc.c rtl8195a_pwm.c rtl8195a_ssi.c rtl8195a_timer.c rtl8195a_uart.c
  group SDRAM
    ../../../component/common/api/platform/: stdlib_patch.c
  group SDRAM/wigadget
    ../../../component/common/application/wigadget/: cloud_link.c shtc1.c wigadget.c
  group src
    ../../src/: zc_hf_adpter.c zc_hf_adpter.h
  group src/AC/inc
    ../../src/AC/inc/: ac_api.h ac_cfg.h ac_hal.h
  group src/AC/src
    ../../src/AC/src/: ac_api.c ac_hal.c
  group src/polarssl
    ../../../component/common/network/ssl/polarssl-1.3.8/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net.c oid.c padlock.c pbkdf2.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group src/ssl_ram_map
    ../../../component/common/network/ssl/ssl_ram_map/rom/: rom_ssl_ram_map.c
    ../../../component/common/network/ssl/ssl_ram_map/: ssl_ram_map.c
  group src/ZC/inc/aes
    ../../src/ZC/inc/aes/: aes.h aes_locl.h
  group src/ZC/inc/tropicssl
    ../../src/ZC/inc/tropicssl/: bignum.h bn_mul.h rsa.h secconfig.h
  group src/ZC/inc/zc
    ../../src/ZC/inc/zc/: zc_bc.h zc_client_manager.h zc_cloud_event.h zc_common.h zc_configuration.h zc_message_queue.h zc_module_config.h zc_module_interface.h zc_protocol_controller.h zc_protocol_interface.h zc_sec_engine.h zc_timer.h
  group src/ZC/src/aes
    ../../src/ZC/src/aes/: aes_cbc.c aes_core.c
  group src/ZC/src/crc
    ../../src/ZC/src/crc/: crc.c
  group src/ZC/src/tropicssl
    ../../src/ZC/src/tropicssl/: bignum.c rsa.c
  group src/ZC/src/zc
    ../../src/ZC/src/zc/: zc_bc.c zc_client_manager.c zc_cloud_event.c zc_common.c zc_configuration.c zc_message_queue.c zc_moudle_manager.c zc_protocol_controller.c zc_sec_engine.c zc_timer.c
  group user
    ../src/: main.c
  group utilities
    ../../../component/common/utilities/: cJSON.c uart_socket.c webserver.c xml.c
  group utilities/example
    ../../../component/common/example/: example_entry.c
    ../../../component/common/example/googlenest/: example_google.c
    ../../../component/common/example/mcast/: example_mcast.c
    ../../../component/common/example/mdns/: example_mdns.c
    ../../../component/common/example/socket_select/: example_socket_select.c
    ../../../component/common/example/ssl_download/: example_ssl_download.c
    ../../../component/common/example/uvc/: example_uvc.c
    ../../../component/common/example/wlan_fast_connect/: example_wlan_fast_connect.c
    ../../../component/common/example/xml/: example_xml.c
